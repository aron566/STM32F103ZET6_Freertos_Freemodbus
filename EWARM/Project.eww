<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F103ZET6_PRJ.ewp</path>
  </project>
  <batchBuild />
</workspace>
